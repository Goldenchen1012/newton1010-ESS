# Keil uVision project HVESS.uvprojx, settings and files
target HVESS_Normal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: HVESS_Norman_Vxx +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32L496xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_144,BSPSMPS,USE_STM32L4XX_NUCLEO_144_SMPS,USE_ADP5301ACBZ
  c misc: --C99
  c include: ../Inc;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32L4xx_Nucleo_144;..\..\..\User;..\..\..\HAL;..\..\..\Lib;..\..\..\Config_Common;..\..\..\AppProtect;..\..\..\APP;..\..\..\Lib\SMP;..\..\..\Drivers\SMP;..\..\..\BSP;..\..\..\Drivers\BSP\STM32L496V_Davinci;..\..\..\API;..\..\..\AppCommunication;..\..\..\Drivers\W5500;..\..\..\RTT;..\..\..\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x50000
  group Version
    ./: Version.s
  group StartUp
    ./: startup_stm32l496xx.s
  group User
    ../../../User/: system_stm32l4xx.c main.c stm32l4xx_hal_msp.c smp_it.c
  group APP
    ../../../APP/: AppProjectHvEss.c AppGauge.c AppBalance.c AppBms.c AppButton.c AppProjectTest.c smp_log_managment.c AppProjectHvEss_IR.c
  group AppProtect
    ../../../AppProtect/: AppProtect.c ApiProtectUvp.c ApiProtectOvp.c ApiProtectCocp.c ApiProtectCotp.c ApiProtectCutp.c ApiProtectDocp.c ApiProtectDotp.c ApiProtectDutp.c
  group AppCommunication
    ../../../AppCommunication/: AppSerialUartDavinci.c AppSerialCanDavinci.c AppSerialCanDavinciNotification.c AppSerialCanDavinciCmd.c AppSerialCanDavinciParameter.c AppSerialCanDavinciCommon.c AppSerialCanDavinciDebug.c AppSerialCanDavinciBaseCmd.c AppSerialCanDavinciFirmwareUpgrade.c AppTcpipSmp.c
  group API
    ../../../API/: ApiRelayControl.c ApiScuTemp.c ApiSignalFeedback.c ApiSystemFlag.c ApiRamData.c ApiSysPar.c ApiFuFlashRom.c ApiFu.c ApiEventFlashRom.c ApiIRMonitoring.c ApiModbusTCPIP.c ApiCanbusPkgFu.c
  group BSP
    ../../../BSP/: DavinciBsp_Rev1.c DavinciBsp_Rev2.c
  group HAL
    ../../../HAL/: HalAfe.c HalEEPromSTM32L4xx.c HalRtcSTM32L4xx.c HalSpiSTM32L4xx.c HalTimerSTM32L4xx.c HalAfeBq796xx.c HalAfeADS7946.c HalBsp.c HalRamSTM32L4xx.c HalSpirom.c
  group LIB
    ../../../Lib/: LibAfe.c LibAvgWeight.c LibButton.c LibCan.c LibCellBalance.c LibCrc32.c LibFaultLog.c LibFifo.c LibLedControl.c LibMos.c LibProtect.c LibProtectOv.c LibRegister.c LibStateMachine.c LibSwTimer.c LibHwTimer.c LibNtc.c LibCalibration.c LibData.c
  group Lib/SMP
    ../../../Lib/SMP/: smp_fifo.c smp_can_fifo.c smp_fifo_flash.c
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
  group Drivers/BSP/STM32L496V_Davinci
    ../../../Drivers/BSP/STM32L496V_Davinci/: stm32l4xx_Davinci.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Drivers/SMP
    ../../../Drivers/SMP/: smp_drv_bq796xx.c smp_gpio.c smp_uart.c smp_can.c smp_adc.c smp_spi_DMA.c smp_ADS7946_Driver.c smp_w5500_DMA.c smp_max7219.c smp_MX25L_Driver.c smp_TLC6C5912.c
  group RTT
    ../../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Test
    ../../../Test/: Test_TLC6C5912.c Test_max7219.c Test_AppProjectHvEss.c Test_MX25L_Driver.c Test_ADS7946_Driver.c Test_ApiIRMonitoring.c Test_drv_bq796xx.c Test_ADC.c Test_log_managment.c
target HVESS_BootMode (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.0
  cpu: as above
  output: HVESS_Bootmode_Vxx +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_144,BSPSMPS,USE_STM32L4XX_NUCLEO_144_SMPS,USE_ADP5301ACBZ, USE_BOOTLOADER
  c misc: --C99 --pointer_alignment=4
  c include: ../Inc;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32L4xx_Nucleo_144;..\..\..\User;..\..\..\Config_Common;..\..\..\Lib;..\..\..\HAL;..\..\..\APP;..\..\..\AppProtect;..\..\..\Lib\SMP;..\..\..\Drivers\SMP;..\..\..\BSP;..\..\..\Drivers\BSP\STM32L496V_Davinci;..\..\..\API;..\..\..\AppCommunication
  asm define: __USE_BOOTLOADER
  memory RVCT4: ROM 0x8004200 size 0x100000
  memory RVCT9: RAM 0x20000020 size 0x3f000
software components: CMSIS:CORE 4.3.0
